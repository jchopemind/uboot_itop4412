## board/samsung/zj4412/Kconfig
```kconfig
if TARGET_ZJ4412

config SYS_BOARD
	default "zj4412"

config SYS_VENDOR
	default "samsung"

config SYS_CONFIG_NAME
	default "zj4412"

endif
```
